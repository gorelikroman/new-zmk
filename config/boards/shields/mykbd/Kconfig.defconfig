## config/boards/shields/mykbd/Kconfig.shield
```kconfig
config ZMK_SHIELD_MYKBD
    bool "MyKBD keyboard shield"
    depends on ZMK_KEYBOARD
```
